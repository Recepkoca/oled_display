## Kconfig
```kconfig
menuconfig DRIVERS_OLED_DISPLAY
	bool "Sh1106_notify"
	default n
	---help---
		Enable support for i2c screen
```
